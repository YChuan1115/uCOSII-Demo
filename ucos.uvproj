# Keil uVision project ucos.uvproj, settings and files
target ucos (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ucos +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\app;.\bsp;.\cmsis;.\inc;.\os;.\ports;.\led;.\lcd;.\ui;.\adc;.\touch;.\exti;.\motor;.\beep
  asm include: .\inc;.\cmsis;.\app;.\os;.\ports;F:\UCOS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./startup/: startup_stm32f10x_md.s
  group os
    ./os/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group app
    ./app/: app.c app.h app_cfg.h os_cfg.h includes.h main.c delay.c delay.h var.h
  group ports
    ./ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group bsp
    ./bsp/: bsp.c bsp.h
  group led
    ./led/: led.c led.h
  group driver
    ./driver/: stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c stm32f10x_exti.c misc.c
  group inc
    ./inc/: assert.h stm32f10x.h stm32f10x_gpio.h stm32f10x_rcc.h system_stm32f10x.h misc.h stm32f10x_exti.h
  group lcd
    ./lcd/: lcd.c char.h lcd.h num.h
  group ui
    ./ui/: base.c base.h button.c button.h cursor.c cursor.h edit.c edit.h keymap.c keymap.h main_ui.c main_ui.h prog.c prog.h text.c text.h title.c title.h
  group adc
    ./adc/: adc.c adc.h
  group touch
    ./touch/: touch.h touch.c
  group cmsis
    ./cmsis/: core_cm3.c core_cm3.h
  group exti
    ./exti/: exti.c exti.h
  group motor
    ./motor/: motor.c motor.h
  group beep
    ./beep/: beep.c beep.h
